# IAR project HytMsg.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\FWLIB\cmsis\interface; ..\..\FWLIB\driver\interface; ..\..\STM32_EVAL; ..\..\STM32_EVAL\Common; ..\..\STM32_EVAL\STM3210B_EVAL; ..\..\STM32_EVAL\STM3210C_EVAL; ..\..\STM32_EVAL\STM3210E_EVAL; ..\..\STM32_EVAL\STM32100B_EVAL; ..\source; ..\source\App
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Third_Party\FreeRTOS7.5.3\Source
  OBJCOPY.OOCOutputFile: HytMsg.bin
  ILINK.IlinkOutputFile: Demo_UART.out
  ILINK.IlinkIcfFile: HytMsg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group DOC
    ../../DOC/: Modification History.txt
  group FWLIB/cmsis
    ../../FWLIB/cmsis/source/: core_cm3.c system_stm32f10x.c
  group FWLIB/cmsis/startup
    ../../FWLIB/cmsis/startup/: startup_stm32f10x_md.s
  group FWLIB/driver
    ../../FWLIB/driver/source/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_EVAL
    ../../STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
    ../../STM32_EVAL/: stm32_eval.h
  group USER
    ../source/: bluetooth.c main.c usart.c usart.h
    ../../FWLIB/cmsis/source/: stm32f10x_it.c
  group USER/App
    ../source/App/: app.c app.h
  group USER/Lib
    ../source/Lib/: convert.c convert.h myqueue.c
  group USER/Log
    ../source/log/: log.c
  group USER/Radio
    ../source/radio/: hdpep.c hdtap.c hdtap.h hrnp.c message.c physical.c
