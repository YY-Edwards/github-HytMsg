# IAR project Backup of HytMsg.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\FWLIB\cmsis\interface; ..\..\FWLIB\driver\interface; ..\..\USER\interface; ..\..\STM32_EVAL; ..\..\STM32_EVAL\common; ..\..\STM32_EVAL\stm3210b_eval; ..\..\STM32_EVAL\stm3210c_eval; ..\..\STM32_EVAL\stm3210e_eval; ..\..\STM32_EVAL\stm32100b_eval; ..\..\Third_Party\FreeRTOS7.5.3\Source\include; ..\..\Third_Party\FreeRTOS7.5.3\Source\portable\GCC\ARM_CM3; ..\..\Third_Party\FreeRTOS7.5.3\Source; ..\source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Third_Party\FreeRTOS7.5.3\Source
  OBJCOPY.OOCOutputFile: HytMsg.bin
  ILINK.IlinkOutputFile: Demo_UART.out
  ILINK.IlinkIcfFile: HytMsg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group DOC
    ../../DOC/: Modification History.txt
  group FWLIB/cmsis
    ../../FWLIB/cmsis/source/: core_cm3.c system_stm32f10x.c
  group FWLIB/cmsis/startup
    ../../FWLIB/cmsis/startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group FWLIB/driver
    ../../FWLIB/driver/source/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_EVAL
    ../../STM32_EVAL/STM32100B_EVAL/: stm32100b_eval_lcd.c
    ../../STM32_EVAL/: stm32_eval.c
  group USER
    ../source/: bluetooth.c main.c usart.c usart.h
    ../../FWLIB/cmsis/source/: stm32f10x_it.c
  group USER/Lib
    ../source/Lib/: convert.c convert.h myqueue.c
  group USER/Log
    ../source/log/: log.c
  group USER/Radio
    ../source/radio/: hdpep.c hrnp.c message.c physical.c
