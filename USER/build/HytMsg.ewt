<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>DOC</name>
    <file>
      <name>$PROJ_DIR$\..\..\DOC\Modification History.txt</name>
    </file>
  </group>
  <group>
    <name>FWLIB</name>
    <group>
      <name>cmsis</name>
      <group>
        <name>startup</name>
        <file>
          <name>$PROJ_DIR$\..\..\FWLIB\cmsis\startup\startup_stm32f10x_hd.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\FWLIB\cmsis\startup\startup_stm32f10x_md.s</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\FWLIB\cmsis\source\core_cm3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\FWLIB\cmsis\source\system_stm32f10x.c</name>
      </file>
    </group>
    <group>
      <name>driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\FWLIB\driver\source\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\FWLIB\driver\source\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\FWLIB\driver\source\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\FWLIB\driver\source\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\FWLIB\driver\source\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\FWLIB\driver\source\stm32f10x_usart.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32_EVAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\STM32_EVAL\STM32100B_EVAL\stm32100b_eval_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM32_EVAL\stm32_eval.c</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <group>
      <name>Lib</name>
      <file>
        <name>$PROJ_DIR$\..\source\Lib\convert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\source\Lib\convert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\source\Lib\myqueue.c</name>
      </file>
    </group>
    <group>
      <name>Log</name>
      <file>
        <name>$PROJ_DIR$\..\source\log\log.c</name>
      </file>
    </group>
    <group>
      <name>Radio</name>
      <file>
        <name>$PROJ_DIR$\..\source\radio\hdpep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\source\radio\hrnp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\source\radio\message.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\source\radio\physical.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\source\bluetooth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\FWLIB\cmsis\source\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\source\usart.h</name>
    </file>
  </group>
</project>


